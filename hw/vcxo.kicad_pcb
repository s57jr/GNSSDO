# Repository s57jr/GNSSDO

## KiCad design hw/vcxo.kicad_pcb

Parts:
C1, C2: 15p; C_0805_HandSoldering
C3, C5: 4.7u; C_0805_HandSoldering
C4, C6, C8, C11, C15, C22, C24, C27, C28, C35, C38, C39: 100n; C_0805_HandSoldering
C7: 3.3n; C_Disc_D9.0mm_W2.5mm_P5.00mm
C9: 10n; C_Disc_D9.0mm_W2.5mm_P5.00mm
C10, C13, C23, C25, C36, C37: 10u; C_0805_HandSoldering
C12, C29, C33: 1n; C_0805_HandSoldering
C14: C_Small; C_0805_HandSoldering
C16, C19, C26: 47p; C_0805_HandSoldering
C17: 2p2; C_0805_HandSoldering
C21: 5p6; C_0805_HandSoldering
C30, C32: 80p; C_Disc_D9.0mm_W2.5mm_P5.00mm
C31: 170p; C_0805_HandSoldering
C34: 10u; CP_Elec_4x5.8
D1: D; Pin_Header_Straight_1x02_Pitch2.54mm
D2: D_Schottky; D_SOD-523
J1, J2, J3, J4, J5, J6: Conn_01x01; Pin_Header_Straight_1x01_Pitch2.00mm
L1: 150n; L_Taiyo-Yuden_NR-30xx_HandSoldering
L2, L4: 150n; L_0805_HandSoldering
L3, L7, L8: 2.2u; L_Taiyo-Yuden_NR-30xx_HandSoldering
L5, L6: 350n; L_0603_HandSoldering
P1: CONN_01X04; Pin_Header_Straight_1x04_Pitch2.54mm
P2: BNC; SMA_sidemount
P3: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm
R1: R_Small; R_1206_HandSoldering
R2: 4.7k; R_0805_HandSoldering
R3: 2k; R_1206_HandSoldering
R4, R7: 22; R_0805_HandSoldering
R5: 5k6; R_1206_HandSoldering
R6: 1k; R_0805_HandSoldering
U1: DAC1220E; SSOP-16_3.9x4.9mm_Pitch0.635mm
U2: ISL60002; SOT-23
U3: TCVCXO_LFTVXO076344; LFTVXO076344
U4: AP1117D33; SOT-223-3_TabPin2
U5: LTC6752HS5; SOT-23-5_HandSoldering
U6: SN74LVC2G74; VSSOP-8_2.3x2mm_Pitch0.5mm
U7, U8: BF776; SOT343
Y1: 2MHz; Crystal_HC18-U_Vertical

Connections:
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.1, C8.1, C10.1, C11.2, C13.2, C14.2, C15.1, C16.2, C19.2, C22.1, C23.1, C24.1, C25.1, C26.2, C27.1, C28.1, C30.1, C31.1, C32.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, L2.2, P1.4, P2.2 (Ext), P3.1, R6.2, U1.4 (DGND), U1.13 (AGND), U1.14 (~CS), U2.3 (GND), U3.2 (GND), U4.1 (GND/ADJ), U5.2 (GND), U5.4 (IN_n), U6.4 (GND), U7.2 (E), U7.4 (E), U8.2 (E), U8.4 (E)
unnamed: C1.1, U1.2 (Xout), Y1.1
unnamed: C2.1, U1.3 (Xin), Y1.2
unnamed: C7.1, R1.2, U1.11 (Vout)
unnamed: C7.2, U1.10 (C2)
unnamed: C9.1, U1.9 (C1)
unnamed: C9.2, C11.1, R3.2, U1.12 (Vref), U2.2 (Vout)
unnamed: C12.1, R2.1, U7.1 (B)
unnamed: C12.2, U3.4 (out)
unnamed: C13.1, R3.1
unnamed: C14.1, R1.1, U3.1 (Vc)
unnamed: C15.2, L1.1, R4.1
unnamed: C16.1, C17.2, L1.2, R2.2, U7.3 (C)
unnamed: C17.1, C19.1, C21.2, L2.1
unnamed: C21.1, R5.2, R6.1, U8.1 (B)
unnamed: C22.2, C23.2, L3.1, U3.5 (Vs)
unnamed: C24.2, L4.1, R7.1
unnamed: C25.2, L3.2, U4.2 (VO)
unnamed: C26.1, L4.2, R5.1, U5.3 (IN_p), U8.3 (C)
unnamed: C29.1, C30.2, L5.2
unnamed: C29.2, U6.5 (Q)
unnamed: C31.2, L5.1, L6.2
unnamed: C32.2, C33.1, L6.1
unnamed: C33.2, P2.1 (In)
unnamed: C34.2, C35.2, D2.1 (K), L7.1, L8.1
unnamed: D1.1 (K), P1.2, U1.15 (SDIO)
unnamed: D1.2 (A), P1.1
unnamed: D2.2 (A), P3.2
unnamed: P1.3, U1.16 (SCLK)
unnamed: U5.1 (out), U6.1 (clk)
unnamed: U6.2 (D), U6.3 (~Q)
VAA: C3.2, C6.2, C8.2, C10.2, C27.2, C28.2, C36.2, C38.2, J3.1, J4.1, J5.1, J6.1, L7.2, R4.2, R7.2, U1.5 (AVdd), U2.1 (Vin), U4.3 (VI), U5.5 (Vcc), U6.6 (~CLR), U6.7 (~PRE), U6.8 (Vcc)
VDD: C4.1, C5.1, C37.2, C39.2, J1.1, J2.1, L8.2, U1.1 (DVdd)

Board: 2 copper layers, 72 parts (0 on the bottom side), 33 nets.

## Commit log

2018-04-09 first
2018-04-09 removed thrash
2018-04-09 removed more thrash
2018-04-10 created pcb
2018-04-10 fixed one cap value
2018-04-10 fixed some L value
